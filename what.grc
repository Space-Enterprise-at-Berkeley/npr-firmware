options:
  parameters:
    generate_options: no_gui
    id: what
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: fname
  id: variable
  parameters:
    value: '"firstrealpls"'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: num_pts
  id: variable
  parameters:
    value: int(samp_rate * 0.2)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: update_rate
  id: variable
  parameters:
    value: '0.00001'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 3*(samp_rate/(2*math.pi*fsk_deviation_hz))
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '10000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport time, socket\nfrom collections import deque\n\nip = \"127.0.0.1\"\ndestip = \"10.0.0.42\"\nport = 42069\n\ntesting_check = False\n\ngood_packets, bad_packets = 0, 0\nprevTime = 0\n\ndef checkErrorRate(self):\n    if (time.time() - self.prevTime) > 2:\n        tP = (self.good_packets + self.bad_packets)\n        if (tP > 0):\n            erate = self.good_packets / tP\n            print(f\"% good in last 2 seconds: {erate*100}, total good packets: {self.good_packets}\")\n        else:\n            print(f\"% good in last 2 seconds: --\")\n \n        self.prevTime = time.time()\n        self.good_packets, self.bad_packets = 0, 0\n\n    \n\ndef clean(i, cumctr, preval):\n    \n    #decimates by a factor of 25-ish to eliminated repeated sampling\n    #should've just sampled slower ¯\\_(ツ)_/¯\n    \n    #f = open(\"/Users/sekharm/wtf.txt\", \"a\")\n    #print(i, end = \"\", file=f)\n    #f.close()\n    if len(i) == 0: return\n    out = []\n    ctr = 1\n    cumctr = cumctr\n    preval = preval\n    while (ctr < len(i)):\n        val = i[ctr]\n        if val == '': continue\n        if (val != preval):\n            #print(cumctr/25)\n            out += [preval]*int(round(cumctr/25))\n            cumctr = 0\n        cumctr += 1\n        ctr += 1\n        preval = val\n    return (\"\".join(out), cumctr, preval)\n\n\ndef computeChecksum(buff):\n    sum1, sum2 = 0, 0\n\n    id = buff[0]\n    length = buff[1]\n    timestamp = buff[2:6]\n    checksum = buff[6:8]\n    data = buff[8:]\n\n    sum1 = sum1 + id\n    sum2 = sum2 + sum1\n    sum1, sum2 = (sum1%256), (sum2%256)\n\n\n    sum1 = sum1 + length\n    sum2 = sum2 + sum1\n    sum1, sum2 = (sum1%256), (sum2%256)\n\n    for i in range(4):\n        sum1 = sum1 + timestamp[i]\n        sum2 = sum2 + sum1\n        sum1, sum2 = (sum1%256), (sum2%256)\n    \n    for i in range(length):\n        sum1 = sum1 + data[i]\n        sum2 = sum2 + sum1\n        sum1, sum2 = (sum1%256), (sum2%256)\n\n    return ((sum2 << 8)|sum1)\n\n    \n\n\n\ndef split(self, buff):\n\n    #*flight* packets are combined into one radio packet (max 128 bytes)\n    #so this function splits them into flight packets\n    ctr = 0\n    try:\n        while True:\n            if (len(buff) < 9):\n                return\n            id = buff[0]\n            length = buff[1]\n            timestamp = (buff[2] << 24) + (buff[3] << 16) + (buff[4] << 8) + (buff[5])\n            checksum = (buff[7] << 8) + buff[6]\n\n            #print(f\"id: {id}, length: {length}, timestamp: {timestamp}, checksum: {checksum}, expected checkum: {computeChecksum(buff)}\")\n            #print(f\"buffer length {len(buff)}, expected length {length + 8}\")\n            if (computeChecksum(buff) == checksum):\n                ctr += 1\n                #print(f\"sending packet #{ctr} with id: {id}, length: {length}\")\n                self.good_packets += 1\n                sendover(self, buff)\n            else:\n                # print(\"CHECKSUM ERROR\")\n                self.bad_packets += 1\n            buff = buff[8+length:]\n    except Exception as e:\n        return\n\n\ndef testing_add(self, i):\n    #print(i)\n    self.lastPacketTime = time.time()\n    check = True\n    packet_start = i[0]\n    if (68 < packet_start < 71):\n        f = i[1]\n        for j in range(1, i+[0]*100):\n            if (i[j] != f+j-1):\n                check = False\n    else:\n        check = False\n    if check : self.testctr+=1\n            \n\ndef sendRssiPacket(self, rssi):\n    buff = []\n    buff.append(56)\n    buff.append(2)\n    buff += [0]*6\n    buff.append(int(rssi) % 256)\n    buff.append(min(255, abs(int(rssi) >> 8)))\n    i = computeChecksum(buff)\n    buff[6] = min(255, abs(int(i % 256)))\n    buff[7] = min(255, abs(int(i >> 8)))\n#    print(buff)\n    sendover(self, buff)\n    \n    \ndef sendover(self, buff):\n    #sends a flight packet to the GS\n    \n    if testing_check:\n        testing_add(self, buff)\n\n\n    \n    f = list(destip)\n    f = [ord(i) for i in f]\n    f = [len(f)] + f\n    f += buff\n    \n    self.sock.sendto(bytes(f), (ip, port))\n    \ndef checkPacketTime(self):\n    if (self.testctr == 0): return\n    if (time.time() - self.lastPacketTime) > 3:\n        print(f\"last packet {(time.time() - self.lastPacketTime):.1f}s ago: got {self.testctr}/200 packets -> {(self.testctr/2):.2f}%\\n\")\n        self.testctr = 0\n    \n    \n\ndef parse(self, i, pn):\n    \n    #converts binary data to radio packets, removing noise from either side\n    \n    i = \"\".join([str(j) for j in i])\n    try:\n        j = i.index(\"0010110111010100\")\n    except:\n        print(\"packet not found\")\n        return 0\n    i = i[j+16:]\n    try:\n        length = int(i[:8], 2)\n    except Exception as e:\n        print(f\"#1 - {i[:8]}\")\n    #print(f\"packet #{pn+1}\")\n    #print(f\"found packet #{pn+1} with length {length}\", end =\"\\n\")\n    \n    i=i[24:]\n    #print(\"0x\", end=\" \")\n    out = []\n    for j in range(length):\n        try:\n            s = int(i[:8],2)\n            out.append(s)\n        except Exception as e:\n            print(\"discarded packet\")\n            return 0\n        i=i[8:]\n    #print(out)\n    split(self, out)\n    return 1\n   \n\n    \n   \nclass blk(gr.sync_block):\n    def __init__(self):\n        np.set_printoptions(threshold=np.inf)\n        gr.sync_block.__init__(\n            self,\n            name='yeet',\n            in_sig=[np.byte, np.float32],\n            out_sig=[np.byte]\n        )\n        self.cleanBuffer = \"\"\n        self.fullBuffer = \"\"\n        self.cumPackets = 0\n        self.lastProcessTime = time.time()\n        self.preval = 0\n        self.cumctr = 0\n        self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)\n        self.testctr = 1\n        self.lastPacketTime = 0\n        self.good_packets, self.bad_packets = 0, 0\n        self.prevTime = 0\n        self.rssiDeque = deque(maxlen = 100000)\n        self.rssi = 0\n        self.prevRssiTime = time.time()\n\n    def work(self, input_items, output_items):\n#        print(f\"hi with {len(input_items[0])} samples\")\n\n        checkErrorRate(self)\n\n        if (testing_check): checkPacketTime(self)\n        # t1 = (input_items[1][:] == 1)\n        # t2 = (input_items[0])[t1]\n\n        t2 = input_items[0]\n        \n        for i in input_items[1]: #the avg received power (not necessarily signal strength)\n            self.rssiDeque.append(i)\n            \n        fg = sorted(self.rssiDeque)\n        self.rssi = sum(fg[-300:]) / sum(fg[:300])\n#        print(self.rssi)\n        if (time.time() - self.prevRssiTime > 0.25):\n        \n#            sendRssiPacket(self, self.rssi)\n            self.prevRssiTime = time.time()\n        \n        \n        \n        g = str(t2)\n        bad = ['[', ']', '\\n', ' ', ',']\n        for i in bad:\n            g = g.replace(i, \"\")\n\n        #g is good str.\n        self.fullBuffer += g\n        \n        if len(self.fullBuffer) > 1000:\n            try:\n                (shortened, self.cumctr, self.preval) = clean(self.fullBuffer, self.cumctr, self.preval)\n            except Exception as e:\n                print(\"clean error\")\n                return len(output_items[0])\n            self.fullBuffer = \"\"\n            self.cleanBuffer += shortened\n        \n        \n        if ((time.time() - self.lastProcessTime > 0.001) and len(self.cleanBuffer) > 300):\n            #print(self.cleanBuffer)\n            self.lastProcessTime = time.time()\n            #print(f\"processing {len(self.cleanBuffer)} bits\")\n            s = self.cleanBuffer\n            seq = \"1010101010100010110111010100\"\n            res = [i for i in range(len(s)) if s.startswith(seq, i)]\n            if (res):\n                for i in range(len(res)-1):\n                    packet = self.cleanBuffer[res[i]:res[i+1]]\n                    numparsed = parse(self, packet, self.cumPackets)\n                    #print(f\"got {numparsed} packets, buffer has size {len(self.cleanBuffer)}\")\n                    if (numparsed == 0):\n                        print(f\"parse error - discarded buffer with size {len(self.cleanBuffer)}\")\n                        self.cleanBuffer = \"0\"\n                        return len(output_items[0])\n                    else:\n                        self.cumPackets += numparsed\n                self.cleanBuffer = self.cleanBuffer[res[-1]:]\n                #print(self.cleanBuffer)\n        #print(len(output_items[0]))\n\n        \n        #output_items[0][:] = (input_items[0])[temp]\n        \n        #output_items[0][:] = input_items[0] * self.example_param\n        #return len(output_items[0])\n\n        return len(output_items[0])\n\n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate, 37500, 5000)
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '240000'
    srate: samp_rate
    type: float
    update_time: '0.00000010'
    ymax: '100'
    ymin: '-10'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.00010'
    ymax: '10'
    ymin: '-10'
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: '450003000'
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_0, '1']
- [blocks_multiply_const_xx_0, '0', blocks_moving_average_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
