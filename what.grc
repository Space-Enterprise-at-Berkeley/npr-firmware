options:
  parameters:
    generate_options: qt_gui
    id: what
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: fname
  id: variable
  parameters:
    value: '"firstrealpls"'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: num_pts
  id: variable
  parameters:
    value: int(samp_rate * 0.2)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: update_rate
  id: variable
  parameters:
    value: '0.00001'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 3*(samp_rate/(2*math.pi*fsk_deviation_hz))
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-5'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: '0'
    file: /Users/sekharm/Desktop/sdring/recordingsfr/lfggg.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '10000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*3
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport time\n\ndef clean(i, cumctr, preval):\n    #f = open(\"/Users/sekharm/wtf.txt\", \"a\")\n    #print(i, end = \"\", file=f)\n    #f.close()\n    if len(i) == 0: return\n    out = []\n    ctr = 1\n    cumctr = cumctr\n    preval = preval\n    while (ctr < len(i)):\n        val = i[ctr]\n        if (val != preval):\n            #print(cumctr/25)\n            out += [preval]*int(round(cumctr/25))\n            cumctr = 0\n        cumctr += 1\n        ctr += 1\n        preval = val\n    return (\"\".join(out), cumctr, preval)\ndef parse(i, pn):\n    i = \"\".join([str(j) for j in i])\n    try:\n        j = i.index(\"0010110111010100\")\n    except:\n        print(\"packet not found\")\n        return 0\n    i = i[j+16:]\n    length = int(i[:8], 2)\n    print(f\"found packet #{pn+1} with length {length}:\", end =\" \")\n    \n    i=i[24:]\n    print(\"0x\", end=\" \")\n    for j in range(length):\n        print((\"0\"+hex(int(i[:8],2))[2:])[-2:], end=\" \")\n        i=i[8:]\n    print(\"\")\n    return 1\n   \nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n\n    def __init__(self, output_file_name=\"/dev/null\"):\n        np.set_printoptions(threshold=np.inf)\n        gr.sync_block.__init__(\n            self,\n            name='yeet',   # will show up in GRC\n            in_sig=[np.byte, np.byte],\n            out_sig=[np.byte]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.output_file_name = output_file_name\n        self.cleanBuffer = \"\"\n        self.fullBuffer = \"\"\n        self.cumPackets = 0\n        self.lastProcessTime = time.time()\n        self.preval = 0\n        self.cumctr = 0\n        #f = open(self.output_file_name, \"w\")\n        #f.close()\n\n    def work(self, input_items, output_items):\n#        print(f\"hi with {len(input_items[0])} samples\")\n        \n        t1 = (input_items[1][:] == 1)\n        t2 = (input_items[0])[t1]\n        \n        g = str(t2)\n        bad = ['[', ']', '\\n', ' ', ',']\n        for i in bad:\n            g = g.replace(i, \"\")\n\n        #g is good str.\n        self.fullBuffer += g\n        \n        if len(self.fullBuffer) > 1000:\n            (shortened, self.cumctr, self.preval) = clean(self.fullBuffer, self.cumctr, self.preval)\n            self.fullBuffer = \"\"\n            self.cleanBuffer += shortened\n        \n        \n        if ((time.time() - self.lastProcessTime > 0.01) and len(self.cleanBuffer) > 600):\n            #print(self.cleanBuffer)\n            self.lastProcessTime = time.time()\n            #print(f\"processing {len(self.cleanBuffer)} bits\")\n            s = self.cleanBuffer\n            seq = \"1010100010110111010100\"\n            res = [i for i in range(len(s)) if s.startswith(seq, i)]\n            if (res):\n                for i in range(len(res)-1):\n                    packet = self.cleanBuffer[res[i]:res[i+1]]\n                    self.cumPackets += parse(packet, self.cumPackets)\n                self.cleanBuffer = self.cleanBuffer[res[-1]:]\n                #print(self.cleanBuffer)\n        #print(len(output_items[0]))\n\n        \n        #output_items[0][:] = (input_items[0])[temp]\n        \n        #output_items[0][:] = input_items[0] * self.example_param\n        #return len(output_items[0])\n\n        return len(output_items[0])\n\n"
    output_file_name: '"/Users/sekharm/Desktop/sdring/recordingsfr/" + fname + "_cleaned.txt"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import adi, os
      import numpy as np
      from gnuradio import gr
      import zmq, time

      #def set_freq(i):
      #    s = "iio_attr -u ip:192.168.2.1 -c ad9361-phy RX_LO frequency " + str(i)
      #    os.system(s)
      #def set_manual_gain():
      #    s = "iio_attr -u ip:192.168.2.1 -c ad9361-phy voltage0 gain_control_mode manual"
      #    os.system(s)
      #def set_gain_level(i):
      #    s = "iio_attr -i -u ip:192.168.2.1 -c ad9361-phy voltage0 hardwaregain " + str(i)
      #    os.system(s)
      #def set_rf_bandwidth(i):
      #    s = "iio_attr -i -u ip:192.168.2.1 -c ad9361-phy voltage0 rf_bandwidth " + str(i)
      #    os.system(s)

      class blk(gr.sync_block):


          def __init__(self):
              self.sdr = adi.Pluto('ip:192.168.2.1')
              self.sample_rate = int(1e6)
              self.center_freq = 450008000
              self.num_samps = int(10000)


      #        set_freq(self.center_freq)
      #        set_manual_gain()
      #        set_gain_level(30)
      #        set_rf_bandwidth(40000)
              
              self.sdr.rx_buffer_size = self.num_samps
      #
              gr.sync_block.__init__(
                  self,
                  name='t2',
                  in_sig=[np.float32],
                  out_sig=[np.complex64]
              )
              self.starting = 1
          def work(self, input_items, output_items):
              print("called")
              if (self.starting == 1):
                  self.sdr.rx_destroy_buffer()
                  self.starting = 0;
              buf = self.sdr.rx()
              output_items[0] = buf
              print(len(buf))
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport adi, os, random\n\ndef setinits():\n    commands = [\n                \"iio_attr -i -u ip:192.168.2.1 -c ad9361-phy voltage0 sampling_frequency 3000000\"\n                \"iio_attr -i -u ip:192.168.2.1 -c ad9361-phy voltage0 gain_control_mode manual\"\n                \"iio_attr -i -u ip:192.168.2.1 -c ad9361-phy voltage0 hardwaregain 71\"\n                \"iio_attr -u ip:192.168.2.1 -c ad9361-phy altvoltage0 frequency 450008000\"\n    ]\n    print(\"hii\")\n    for i in commands:\n        os.system(i)\n    \n\n\n    \n    \n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='ayo',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        self.ctr = 0\n        self.sdr = adi.Pluto('ip:192.168.2.1')\n        self.sdr.rx_buffer_size = 50000\n        self.sdr.rx_destroy_buffer()\n        self.starting = 1\n        \n        self.startptr = 0\n        self.endptr = 0\n        self.jankbuff = np.zeros(1000000) + 0.0j\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n    def refillbuffer(self):\n        start, end = self.startptr, self.endptr\n        \n        f = self.sdr.rx() / (2**14)\n        self.jankbuff[:end-start] = self.jankbuff[start:end]\n        self.jankbuff[end-start:end-start+50000][:] = f\n        \n        #print(f\"filledbuffer: start: {start}, end: {end}, newend: {end-start+4096}\")\n        print(\"refilled buffer\" + str(random.randint(0, 9)))\n        self.endptr = end-start+50000\n        self.startptr = 0\n        \n    def work(self, input_items, output_items):\n        if self.starting==1:\n            setinits()\n            self.starting = 0\n        \n        \n        #print(\"called\")\n        \n        #print(f\"sdrlen {len(recv)}, output_items[0]len {len(output_items[0])}, input_items[0] len {len(input_items[0])}\")\n        #print(len(output_items[0]))\n        \n        l = len(input_items[0])\n        \n        if (self.endptr - self.startptr) < l:\n            self.refillbuffer()\n            \n        output_items[0][:] = self.jankbuff[self.startptr:self.startptr+l]\n        self.startptr = self.startptr + l\n        #print(output_items[0][:50])\n        \n        return len(output_items[0])\n        \n        \n\n"
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '3'
    taps: firdes.low_pass(1, samp_rate*3, 60000, 20000)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate, 37500, 5000)
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1240000'
    srate: samp_rate
    type: float
    update_time: '0.00000010'
    ymax: '1000'
    ymin: '-30'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '100000'
    srate: samp_rate
    type: float
    update_time: '0.000010'
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '102400'
    srate: samp_rate
    type: complex
    update_time: '0.00010'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '1'
    type: ccc
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', epy_block_1, '0']
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_1, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_null_source_0, '0', epy_block_2, '0']
- [blocks_throttle_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_1, '0', qtgui_time_sink_x_2, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [digital_binary_slicer_fb_1, '0', epy_block_0, '1']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_1, '0', blocks_null_sink_1, '0']
- [epy_block_2, '0', rational_resampler_xxx_0, '0']
- [fir_filter_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
